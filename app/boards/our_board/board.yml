## app/boards/our_board/board.yml
```yaml
board:
  name: our_board
  full_name: Our Board 
  vendor: My custom st
  socs:
    - name: stm32f446xx
```
